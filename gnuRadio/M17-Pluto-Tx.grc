options:
  parameters:
    author: SP5WWP/KA1PQK
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: M17 transmitter
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Transmit Frequency
    start: '433000000'
    step: '10.0'
    stop: '435000000'
    value: '434004170'
  states: {}
- name: inner
  id: variable_qtgui_range
  parameters:
    label: Inner dev.
    start: '100.0'
    step: '10.0'
    stop: '1000.0'
    value: '620'
  states: {}
- name: offset
  id: variable_qtgui_range
  parameters:
    label: offset
    start: '-5.0'
    step: '0.01'
    stop: '5.0'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4800*128
  states: {}
- name: source_select
  id: variable_qtgui_toggle_button_msg
  parameters:
    initPressed: 'False'
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: (2.0*3.1415926535*inner)/(128.0*4800.0)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '3'
    freq: '2400'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate/128
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: offset
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\Radio\OneDrive\Documents\HamRadio\Experimental\M17\ka1pqk_m17.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '2'
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: source_select
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: (-3.0, 3.0)
  states: {state: disabled}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: 1.0, 3.0, -1.0, -3.0
  states: {state: disabled}
- name: digital_chunks_to_symbols_xx_1
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[1.0, 3.0, -1.0, -3.0]'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: 64*4800
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: freq
    samplerate: samp_rate
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: 128*64
    srate: samp_rate
    type: float
    ymax: '5'
    ymin: '-5'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    gain: '128'
    interp: '128'
    ntaps: 11*128+1
    samp_rate: '128'
    sym_rate: '1.0'
    type: interp_fir_filter_fff
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_selector_0, '1']
- [analog_frequency_modulator_fc_0, '0', iio_pluto_sink_0, '0']
- [blocks_add_const_vxx_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_file_source_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_chunks_to_symbols_xx_1, '0']
- [blocks_selector_0, '0', blocks_add_const_vxx_0, '0']
- [digital_chunks_to_symbols_xx_1, '0', blocks_selector_0, '0']
- [root_raised_cosine_filter_0, '0', analog_frequency_modulator_fc_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
