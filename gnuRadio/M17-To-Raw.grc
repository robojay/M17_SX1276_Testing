options:
  parameters:
    author: SP5WWP / KA1PQK
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: M17 transmitter
  states: {}

blocks:
- name: RRC_upsample
  id: variable
  parameters:
    value: '10'
  states: {}
- name: baseband_sample_rate
  id: variable
  parameters:
    value: '4800'
  states: {}
- name: modulation_step
  id: variable
  parameters:
    value: '61'
  states: {}
- name: offset
  id: variable
  parameters:
    value: '128'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: baseband_sample_rate * RRC_upsample
  states: {}
- name: symbol_deviation
  id: variable
  parameters:
    value: '700'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: offset
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\Radio\OneDrive\Documents\HamRadio\Experimental\M17\M17_TX.RAW
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\Radio\OneDrive\Documents\HamRadio\Experimental\M17\ka1pqk_m17.bin
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1*symbol_deviation/modulation_step'
    type: float
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '2'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_chunks_to_symbols_xx_1
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[1.0, 3.0, -1.0, -3.0]'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: RRC_upsample*64
    srate: samp_rate
    type: float
    ymax: '256'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: RRC_upsample*64
    srate: samp_rate
    type: float
    ymax: '256'
    ymin: '0'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    gain: RRC_upsample
    interp: RRC_upsample
    ntaps: 11*128+1
    samp_rate: samp_rate
    sym_rate: baseband_sample_rate
    type: interp_fir_filter_fff
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_float_to_uchar_0, '0', blocks_file_sink_0, '0']
- [blocks_float_to_uchar_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_chunks_to_symbols_xx_1, '0']
- [blocks_throttle_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_chunks_to_symbols_xx_1, '0', root_raised_cosine_filter_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
